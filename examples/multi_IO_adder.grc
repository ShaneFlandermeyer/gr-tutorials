options:
  parameters:
    generate_options: qt_gui
    id: multi_IO_adder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '5'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '20'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: tutorials_adder_xx_0
  id: tutorials_adder_xx
  parameters:
    type: float
  states: {state: disabled}
- name: tutorials_adder_xx_2
  id: tutorials_adder_xx
  parameters:
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', tutorials_adder_xx_0, '0']
- [analog_const_source_x_0_0, '0', tutorials_adder_xx_0, '1']
- [analog_sig_source_x_0, '0', tutorials_adder_xx_2, '0']
- [analog_sig_source_x_0_0, '0', tutorials_adder_xx_2, '1']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0, '0']
- [tutorials_adder_xx_0, '0', blocks_throttle_0_0, '0']
- [tutorials_adder_xx_2, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
